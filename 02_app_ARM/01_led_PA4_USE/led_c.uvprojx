# Keil uVision project led_c.uvprojx, settings and files
target led_c (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: led_c +hex
  AfterMake: fromelf  --bin  --output=led.bin  Objects\led_c.axf
  AfterMake: fromelf  --text  -a -c  --output=led.dis  Objects\led_c.axf
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group main
    ./: main.c
  group cpu
    ./: start.s
